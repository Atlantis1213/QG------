# Keil uVision project RTOX.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C52RC STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: RTOX +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\Hardware;..\RTX51-Tiny;..\User
  group Hardware
    ../Hardware/: Seg.c Seg.h
  group User
    ../User/: main.c
  group RTX51-Tiny
    ../RTX51-Tiny/: Conf_tny.A51 RTX51TNY.LIB
